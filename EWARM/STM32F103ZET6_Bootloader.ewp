# IAR project STM32F103ZET6_Bootloader.ewp, settings and files
configuration STM32F103ZET6_Bootloader (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\APP\Main; ..\APP\Component; ..\Utilities; ..\Middlewares\Third_Party\Easylogger\inc; ..\Middlewares\Third_Party\Easylogger\port; ..\Middlewares\Third_Party\FAL\inc; ..\Middlewares\Third_Party\FAL\port; ..\Middlewares\Third_Party\FATFS\port; ..\Middlewares\Third_Party\FATFS\source; ..\Middlewares\Third_Party\LetterShell\Src; ..\Middlewares\Third_Party\LetterShell\Port; ..\Middlewares\Third_Party\SFUD\inc; ..\Middlewares\Third_Party\SFUD\port; ..\Middlewares\Third_Party\Easylogger\plugins\file; ..\Middlewares\Third_Party\Easylogger\plugins\flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: STM32F103ZET6_Bootloader.hex
  ILINK.IlinkOutputFile: STM32F103ZET6_Bootloader.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP/Component
    ../APP/Component/: Flash_Port.c LED_Port.c LOG_Port.c RTC_Port.c Timer_Port.c UART_Port.c
  group APP/Main
    ../APP/Main/: User_Main.c
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c rtc.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_custom_hid_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/Easylogger/port
    ../Middlewares/Third_Party/Easylogger/port/: elog_port.c
  group Middlewares/Easylogger/src
    ../Middlewares/Third_Party/Easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Middlewares/FAL/port
    ../Middlewares/Third_Party/FAL/port/: fal_cfg.h fal_flash_sfud_port.c fal_flash_stm32f1_port.c
  group Middlewares/FAL/src
    ../Middlewares/Third_Party/FAL/src/: fal.c fal_flash.c fal_partition.c
  group Middlewares/FATFS/port
    ../Middlewares/Third_Party/FATFS/port/: disk_port.c ffsystem.c
  group Middlewares/FATFS/src
    ../Middlewares/Third_Party/FATFS/source/: diskio.c diskio.h ff.c ff.h ffunicode.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/LetterShell/port
    ../Middlewares/Third_Party/LetterShell/Port/: Shell_Port.c
  group Middlewares/LetterShell/src
    ../Middlewares/Third_Party/LetterShell/Src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group Middlewares/SFUD/port
    ../Middlewares/Third_Party/SFUD/port/: sfud_port.c
  group Middlewares/SFUD/src
    ../Middlewares/Third_Party/SFUD/src/: sfud.c sfud_sfdp.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Utilities
    ../Utilities/: CircularQueue.c utilities.c utilities_crc.c YModem.c
